## qemu/hw/pv_dev/Kconfig
```kconfig
config HUAWEI_ZCDEV
    default y if PCI_DEVICES
    depends on ZCDEV && PCI && MSI_NONBROKEN
```
